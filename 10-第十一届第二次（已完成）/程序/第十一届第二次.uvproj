# Keil uVision project 第十一届第二次.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 第十一届第二次 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: key.c main.c key.h iic.c onewire.c iic.h onewire.h
