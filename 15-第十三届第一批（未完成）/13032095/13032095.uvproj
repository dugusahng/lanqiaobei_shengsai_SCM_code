# Keil uVision project 13032095.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 13032095 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: key.c main.c key.h onewire.c ds1302.c ds1302.h onewire.h
